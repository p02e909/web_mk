# IAR project demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\1 Stu\STM8\project\uart\Library\inc; D:\1 Stu\STM8\project\uart\User; D:\1 Stu\STM8\project\uart\Library\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: demo.out
  group Lib
    ../../Library/src/: stm8s_clk.c stm8s_gpio.c stm8s_uart1.c
  group User
    ../../User/: main.c stm8s_conf.h stm8s_it.h
